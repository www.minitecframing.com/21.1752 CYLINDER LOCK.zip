# Autodesk Inventor assembly: 1108-U01_ASM
## iProperties
Created: 2007-03
Part Number: 1108-U01_ASM
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
